# IAR project coremark.ewp, settings and files
configuration Debug (RISCV, debug)
  General.GDeviceSelect: RV32 RV32
  General.GHeapSize: 0x1000
  ICCRISCV.IccLang: 0
  ICCRISCV.CCOptLevel: 3
  ICCRISCV.CCOptStrategy: 2
  ICCRISCV.CCDefines: ITERATIONS=1000; PERFORMANCE_RUN=1
  ICCRISCV.CCIncludePath2: ..\..\BSP\demosoc\Include; $PROJ_DIR$
  OBJCOPY.OOCOutputFile: coremark.srec
  ILINK.IlinkStackSize: 1
  ILINK.IlinkHeapSize: 1
  ILINK.IlinkOutputFile: coremark.out
  ILINK.IlinkIcfFile: ..\..\BSP\demosoc\demosoc.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (RISCV)
  as the first configuration, except:
  ICCRISCV.CCOptStrategy: 0
  ICCRISCV.CCDefines: NDEBUG
  group BSP
    ../../BSP/demosoc/: demosoc.icf
    ../../BSP/demosoc/Source/: demosoc_gpio.c demosoc_init.c demosoc_stubs.c demosoc_uart.c low_level_init.c
  group Coremark
    ./: core_list_join.c core_main.c core_matrix.c core_portme.c core_state.c core_util.c
