<?xml version="1.0" encoding="UTF-8"?>
<workspace>
    <project>
        <path>$WS_DIR$\Examples\coremark\coremark.ewp</path>
    </project>
    <project>
        <path>$WS_DIR$\Examples\helloworld\hellworld.ewp</path>
    </project>
    <batchBuild />
</workspace>
